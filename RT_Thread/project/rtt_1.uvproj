# Keil uVision project rtt_1.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: rtt_1 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\apps;..\divers;..\..\RT-Thread_1.1.1\include;..\..\RT-Thread_1.1.1\components\finsh;..\third_part\STM32F10x_StdPeriph_Driver\inc;..\..\RT-Thread_1.1.1\libcpu\arm\common;..\..\RT-Thread_1.1.1\libcpu\arm\cortex-m3;..\third_part\CMSIS\CM3\CoreSupport;..\third_part\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group StartUp
    ../apps/: application.c board.c startup.c stm32f10x_it.c
    ../divers/: led.c rtc.c serial.c usart.c
  group cm3
    ../../RT-Thread_1.1.1/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../RT-Thread_1.1.1/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group STM32_StdPeriph
    ../third_part/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../third_part/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../third_part/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../third_part/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group kernel
    ../../RT-Thread_1.1.1/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group Finish
    ../../RT-Thread_1.1.1/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
